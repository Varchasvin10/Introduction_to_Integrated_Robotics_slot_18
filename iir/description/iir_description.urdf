Commit message: Update iir_description.urdf

File: iir/description/iir_description.urdf (robot description, URDF)
Before this commit: robot iir, 8 links, 7 joints
Joints:
- joint lidar3d_joint: origin xyz=0 0 0.1 rpy=0 0 0 -> xyz=0 0 0.1 rpy=0 0 -3.14
